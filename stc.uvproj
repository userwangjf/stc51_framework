# Keil uVision project stc.uvproj, settings and files
target stc (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .
  link misc: REMOVEUNUSED
  group bsp
    ./bsp/: bsp.c STARTUP.A51
  group app
    ./app/: main.c app.c
  group os
    ./os/: os_sch.c
  group module
    ./module/: module.c
